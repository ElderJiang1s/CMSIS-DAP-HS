# Keil uVision project M484.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: M484SIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.3
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: M484 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1UL,DAP_SER_NUM
  c include: .\CORE;.\LIBRARY\inc;.\USER;.\SYSTEM\delay;.\SYSTEM\MALLOC;.\SYSTEM\HSUSBD\HID;.\DAP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group USER
    ./USER/: main.c
  group CORE
    ./CORE/: startup_M480.s system_M480.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/MALLOC/: malloc.c
  group LIBRARY
    ./LIBRARY/src/: clk.c gpio.c bpwm.c can.c crc.c crypto.c eadc.c ebi.c ecap.c emac.c epwm.c fmc.c hsusbd.c i2c.c i2s.c pdma.c qei.c qspi.c retarget.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group HSUSB
    ./SYSTEM/HSUSBD/HID/: descriptors.c hid_transfer.c
  group DAP
    ./DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
